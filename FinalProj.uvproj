# Keil uVision project FinalProj.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: FinalProj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: FIFO.c FIFO.h joystick.c joystick.h LCD.c LCD.h os.c os.h osasm.s PLL.c PLL.h PORTE.c PORTE.h startup.s tm4c123gh6pm.h UART.c UART.h UART_FIFO.c UART_FIFO.h I2C1.c I2C1.h PWM.c PWM.h Cube.c Cube.h RandomNumberGenerator.c RandomNumberGenerator.h buzzer.c buzzer.h numFIFO.c numFIFO.h image.h pages.c pages.h screen.c screen.h Main.c display.c display.h PVZGame.c PVZGame.h ScoreLife.c ScoreLife.h screenStack.c screenStack.h
